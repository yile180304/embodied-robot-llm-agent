# Keil uVision project robot_firmware_runtime.uvprojx, settings and files
target robot_runtime_cortex_m4 (6070000::V6.7::.\ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ESEL ELITTLE
  output: robot_firmware_runtime (library)
  c flags: Optim=1 uC99=1 v6Lang=3
  c misc: -std=c11 -Wall -Wextra -Werror
  c include: ..\firmware_sim;..\firmware_runtime;..\.deps\cJSON;..\.deps\FreeRTOS-Kernel\include;..\.deps\FreeRTOS-Kernel\portable\GCC\ARM_CM4F
  group Protocol
    ../firmware_sim/: robot_protocol.c robot_protocol_json.c
  group Runtime
    ../firmware_runtime/: robot_runtime.c robot_freertos_runtime.c
  group cJSON
    ../.deps/cJSON/: cJSON.c
  group FreeRTOS Kernel
    ../.deps/FreeRTOS-Kernel/: list.c queue.c tasks.c
    ../.deps/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
